# Keil uVision project Project1.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: MKL25Z128xxx4 NXP
  pack: Keil.Kinetis_KLxx_DFP.1.14.0
  cpu: IRAM(0x1FFFF000,0x00004000) IROM(0x00000000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Project1
  AfterMake: Scripts\update_regions_MDK.bat !L
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: --fpmode=fast
  c include: .\Include;.\Profiler
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  group Source
    ./Source/: delay.c LEDs.c main.c queue.c UART.c CMAN_coords.c Geometry.c CMAN_coords2.c Optimization_Additions.c
  group Include
    ./Include/: delay.h Geometry.h GPIO_defs.h LEDs.h queue.h UART.h Optimization_Additions.h
  group Profiler
    ./Profiler/: PIT.c PIT.h profile.c profile.h region.c region.h
software components: CMSIS:CORE 5.0.2, Device:Startup 2.5.0
